# Keil uVision project RoboMaster.uvprojx, settings and files
target STM32F429BITx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoboMaster +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,MPU9250,EMPL_TARGET_STM32F4,USE_DMP,MPL_LOG_NDEBUG=1
  c include: ..\..\Library\CMSIS\Include;..\..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Devices;..\..\Drivers;..\..\Apps;..\..\Devices\MPU;..\..\Devices\MPU\DMP\driver\eMPL;..\..\Devices\MPU\DMP\driver\include;..\..\Devices\MPU\DMP\driver\stm32L;..\..\Devices\MPU\DMP\mllite;..\..\Devices\MPU\DMP\mpl;..\..\Devices\MPU\DMP\eMPL-hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group IFreeRTOS
    ../../IFreeRTOS/: IFreeRTOS.c
  group Apps
    ../../Apps/: Analysis.c PID.c Filter.c slope.c Coordinate.c Chassis_control.c Cloud_control.c Shoot_control.c CurrentSetting.c ANO.c Galvanometer.c
  group User
    ../../User/: main.c math.h Users.c structural.h stm32f4xx_it.c stm32f4xx_conf.h
  group Devices
    ../../Devices/: DR16.c DeviceFlash.c Laser.c ControlVision.c
  group IMU
    ../../Devices/: GY_IMU.c
  group Pc_Control
    ../../Apps/: PC_control.c
  group Drivers
    ../../Drivers/: delay.c LED.c CAN.c TIM.c NVIC.c USART.c
  group startup
    ../../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s startup_stm32f427_437xx.s
    ../../User/: system_stm32f4xx.c
  group Library_StdPeriph
    ../../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Library_dmp
    ../../Devices/MPU/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Library_DSP
    ../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
target STM32F427IIHx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: RoboMaster +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=12000000,USE_STDPERIPH_DRIVER,STM32F427_437xx,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,MPU6500,EMPL_TARGET_STM32F4
  c include: ..\..\Library\CMSIS\Include;..\..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\..\Library\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Devices;..\..\Drivers;..\..\Apps;..\..\Devices\MPU;..\..\Devices\MPU\DMP\driver\eMPL;..\..\Devices\MPU\DMP\driver\include;..\..\Devices\MPU\DMP\driver\stm32L;..\..\Devices\MPU\DMP\mllite;..\..\Devices\MPU\DMP\mpl;..\..\Devices\MPU\DMP\eMPL-hal;..\..\Devices\IMU;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\IFreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
